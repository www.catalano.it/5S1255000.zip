Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Accessories_Ceramica-Catalano_Horizon-Zero-Frame-125.ifc
Time: 2022-10-21T14:49:20
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Horizon / Zero Frame 125
ePset_BIMobjectScript - TOWEL_RAIL: WITH; COLOUR: Scotch_brite; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Horizon / Zero Frame 125; SKU (BO_prodsku): horizon-zero-frame-125-5S1255000; ManufacturName (BO_Manufac): Ceramica Catalano; BrandUrl (BO_brandurl): http://www.catalano.it/; ProductFamily (BO_prodfam): Frames; ProductGroup (BO_prodgroup): Horizon; EditionNumber (BO_edinum): 1; Width (BO_width): 1200; Height (BO_height): 370; Depth (BO_depth): 470; Weight (BO_weight): 9; QR (BO_boqrurl): http://bimobject.com/ceramica-catalano/product/horizon-zero-frame-125-5S1255000; ProductDataUrl (BO_prodaturl): bimobject.com/ceramica-catalano/product/horizon-zero-frame-125-5S1255000; MaterialMain (BO_mainmat): Aluminium; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-accessories1; IfcClassification (BO_ifcclas): Furniture; RegionEurope (BO_europe): All; RegionNorthAmerica (BO_northamerica): All; RegionSouthAmerica (BO_southamerica): All; RegionMiddleEast (BO_middleeast): All; RegionAsia (BO_asia): All; RegionOceania (BO_oceania): All; RegionAfrica (BO_africa): All; RegionAntarctica (BO_antarctica): All
